# IAR project eddystoneBeaconBroadcaster.ewp, settings and files
configuration CC2541EM (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\source\components; ..\..\,,common; ..\..\,,Components\hal\include; ..\..\,,Components\hal\target\CC2541ST; ..\..\,,Components\osal\include; ..\..\,,Components\services\saddr; ..\..\,,Components\ble\include; ..\..\,,Components\ble\controller\CC254x\phy; ..\..\,,Components\ble\controller\CC254x\include; ..\..\,,Components\ble\hci; ..\..\,,Components\ble\host; ..\..\,,Components\ble\ROM; ..\..\,,common\cc2540; ..\..\,,common\npi\npi_np; ..\..\,,Include; ..\..\,,Profiles\Roles\CC254x; ..\..\,,Profiles\Roles; ..\..\,,Profiles\SimpleProfile\CC254x; ..\..\,,Profiles\SimpleProfile
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\,,common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: OSAL_eddystoneBeaconBroadcaster.c eddystoneBeaconBroadcaster.c eddystoneBeaconBroadcaster.h eddystoneBeaconBroadcaster_Main.c
  group APP/Include
    ../Source/components/: ioCC254x_bitdef.h
  group HAL/Common
    ../../,,Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../,,Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../,,Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../,,Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../,,Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2541ST/Config
    ../../,,Components/hal/target/CC2541ST/: hal_board_cfg.h
  group HAL/Target/CC2541ST/Drivers
    ../../,,Components/hal/target/CC2541ST/: hal_acc.c hal_aes.c hal_assert.c hal_bar.c hal_crc.c hal_dma.c hal_flash.c hal_gyro.c hal_humi.c hal_i2c.c hal_interrupt.c hal_irtemp.c hal_keys.c hal_led.c hal_mag.c hal_sensor.c hal_sleep.c hal_startup.c hal_timer.c hal_wait.c
  group HAL/Target/CC2541ST/Includes
    ../../,,Components/hal/target/CC2541ST/: hal_acc.h hal_aes.h hal_bar.h hal_crc.h hal_dma.h hal_gyro.h hal_humi.h hal_i2c.h hal_irtemp.h hal_keys.h hal_mag.h hal_mcu.h hal_sensor.h hal_types.h hal_wait.h
  group LIB
    ../../,,Libraries/CC2541DB/bin/: CC2541_BLE_observ.lib
    ../../,,Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../,,common/npi/npi_np/: npi.c npi.h npi_spi.c npi_uart.c
  group OSAL
    ../../,,Components/ble/include/: bcomdef.h
    ../../,,Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../,,Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../,,Profiles/Roles/: gap.c
    ../../,,Profiles/GATT/: gattservapp_util.c
    ../../,,Profiles/Roles/CC254x/: observer.c observer.h
  group TOOLS
    ../../,,config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../,,common/cc2540/: OnBoard.c OnBoard.h

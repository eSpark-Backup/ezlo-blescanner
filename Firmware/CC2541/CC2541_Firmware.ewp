# IAR project CC2541_Firmware.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: chip=2541
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: source; source\components; source\libraries\uart; source\libraries\i2c; D:\.ide\IAR_Systems\8051\8051\inc; D:\.ide\IAR_Systems\8051\8051\inc\dlib
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2541F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group (top)
    Source/: main.c
  group Components
    Source/components/: hal_types.h ioCC254x_bitdef.h
  group Libraries/i2c
    Source/libraries/i2c/: i2c.c
  group Libraries/uart
    Source/libraries/uart/: print.c uart.c

# IAR project BLE_Scanner.ewp, settings and files
configuration CC2541EM (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; HAL_I2C=TRUE; ZAPP_P1
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Source\common; Source\Components\hal\include; Source\Components\hal\target\CC2540EB; Source\Components\osal\include; Source\Components\services\saddr; Source\Components\ble\include; Source\Components\ble\controller\CC254x\phy; Source\Components\ble\controller\CC254x\include; Source\Components\ble\hci; Source\Components\ble\host; Source\Components\ble\ROM; Source\common\cc2540; Source\common\npi\npi_np; Source\Include; Source\Profiles\Roles\CC254x; Source\Profiles\Roles; Source\Profiles\SimpleProfile\CC254x; Source\Profiles\SimpleProfile
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: Source\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    Source/App/: BLE_Scanner.c BLE_Scanner.h BLE_Scanner_Main.c OSAL_BLE_Scanner.c
  group HAL/Common
    Source/Components/hal/common/: hal_drivers.c print.c
  group HAL/Include
    Source/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h print.h
  group HAL/Target/CC2540EB/Config
    Source/Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    Source/Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_i2c.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    Source/Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group LIB
    Source/Libraries/CC2541DB/bin/: CC2541_BLE_observ.lib
    Source/Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    Source/common/npi/npi_np/: npi.c npi.h
    ../../common/npi/npi_np/: npi_spi.c npi_uart.c
  group OSAL
    Source/Components/ble/include/: bcomdef.h
    Source/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    Source/Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    Source/Profiles/Roles/: gap.c
    Source/Profiles/GATT/: gattservapp_util.c
    Source/Profiles/Roles/CC254x/: observer.c observer.h
  group TOOLS
    config/: buildComponents.cfg
    ./: buildConfig.cfg
    Source/common/cc2540/: OnBoard.c OnBoard.h
